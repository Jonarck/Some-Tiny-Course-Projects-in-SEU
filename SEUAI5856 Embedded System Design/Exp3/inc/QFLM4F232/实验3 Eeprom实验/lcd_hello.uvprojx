# Keil uVision project lcd_hello.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: LM4F232H5QD Texas Instruments
  cpu: IROM(0x00000000,0x40000) IRAM(0x10000000,0x8000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: lcd_hello +hex
  AfterMake: fromelf --bin --output .\rvmdk\lcd_hello.bin .\rvmdk\lcd_hello.axf
  c flags: Optim=1 oTime=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM4F232H5QD TARGET_IS_BLIZZARD_RA1
  c include: .\HARDWARE;..\..\inc;..\..\..\A实验
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  scatter file: .\lcd_hello.sct
  group src
    ./: startup_rvmdk.S soft_i2c_atmel.c
    ./HARDWARE/: lcd.c PCF8574.c
    ../../utils/: uartstdio.c softi2c.c ustdlib.c
  group driver
    ../../driverlib/rvmdk-cm4f/: driverlib-cm4f.lib
    ../../grlib/rvmdk-cm4f/: grlib-cm4f.lib
