# Keil uVision project Exp2.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: LM4F232H5QD Texas Instruments
  pack: Keil.LM4F_DFP.1.0.0
  cpu: IRAM(0x10000000,0x8000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Exp2 +hex
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=2
  c define: rvmdk PART_LM4F232H5QD TARGET_IS_BLIZZARD_RA1
  c include: ..\driverlib;..\grlib;..\inc;..\
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  group lib
    ../driverlib/rvmdk-cm4f/: driverlib-cm4f.lib
    ../grlib/rvmdk-cm4f/: grlib-cm4f.lib
  group user
    ./: main.c
software components: CMSIS:CORE 5.5.0, Device:Startup 1.0.0
